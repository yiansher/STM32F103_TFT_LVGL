# Keil uVision project TFT_TEST.uvprojx, settings and files
target TFT_TEST (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: TFT_TEST +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../GC9A01;../lvgl;../lvgl/src/widgets/animimg;../lvgl/src/widgets/arc;../lvgl/src/widgets/bar;../lvgl/src/widgets/btn;../lvgl/src/widgets/btnmatrix;../lvgl/src/widgets/calendar;../lvgl/src/widgets/canvas;../lvgl/src/widgets/chart;../lvgl/src/widgets/checkbox;../lvgl/src/widgets/colorwheel;../lvgl/src/widgets/dropdown;../lvgl/src/widgets/img;../lvgl/src/widgets/imgbtn;../lvgl/src/widgets/keyboard;../lvgl/src/widgets/label;../lvgl/src/widgets/led;../lvgl/src/widgets/line;../lvgl/src/widgets/list;../lvgl/src/widgets/menu;../lvgl/src/widgets/meter;../lvgl/src/widgets/msgbox;../lvgl/src/widgets/objx_templ;../lvgl/src/widgets/roller;../lvgl/src/widgets/slider;../lvgl/src/widgets/span;../lvgl/src/widgets/spinbox;../lvgl/src/widgets/spinner;../lvgl/src/widgets/switch;../lvgl/src/widgets/table;../lvgl/src/widgets/tabview;../lvgl/src/widgets/textarea;../lvgl/src/widgets/tileview;../lvgl/src/widgets/win;../lvgl/src/core;../lvgl/src/draw/sw;../lvgl/src/draw;../lvgl/src/font;../lvgl/src/hal;../lvgl/src/misc;../lvgl/src/themes/default;../lvgl/src/layouts/flex;../lvgl/src/layouts/grid;../lvgl/src/layouts;../lvgl/porting;../ui;.\sd
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group GC9A01
    ../GC9A01/: GC9A01.c GC9A01.h GC9A01_port.c GC9A01_port.h testpic.h
  group lvgl
    ../lvgl/: lv_conf.h lvgl.h
  group lvgl_porting
    ../lvgl/porting/: lv_port_disp_template.c lv_port_disp_template.h lv_port_fs_template.c lv_port_fs_template.h lv_port_indev_template.c lv_port_indev_template.h
  group lvgl_core
    ../lvgl/src/core/: lv_disp.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_cache_builtin.c lv_img_decoder.c
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl_font
    ../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_hal
    ../lvgl/src/hal/: lv_hal_tick.c
  group lvgl_misc
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_event.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../lvgl/src/widgets/animimg/: lv_animimg.c
    ../lvgl/src/widgets/arc/: lv_arc.c
    ../lvgl/src/widgets/bar/: lv_bar.c
    ../lvgl/src/widgets/btn/: lv_btn.c
    ../lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/widgets/canvas/: lv_canvas.c
    ../lvgl/src/widgets/chart/: lv_chart.c
    ../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../lvgl/src/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../lvgl/src/widgets/img/: lv_img.c
    ../lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/widgets/label/: lv_label.c
    ../lvgl/src/widgets/led/: lv_led.c
    ../lvgl/src/widgets/line/: lv_line.c
    ../lvgl/src/widgets/list/: lv_list.c
    ../lvgl/src/widgets/menu/: lv_menu.c
    ../lvgl/src/widgets/meter/: lv_meter.c
    ../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../lvgl/src/widgets/roller/: lv_roller.c
    ../lvgl/src/widgets/slider/: lv_slider.c
    ../lvgl/src/widgets/span/: lv_span.c
    ../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/widgets/spinner/: lv_spinner.c
    ../lvgl/src/widgets/switch/: lv_switch.c
    ../lvgl/src/widgets/table/: lv_table.c
    ../lvgl/src/widgets/tabview/: lv_tabview.c
    ../lvgl/src/widgets/textarea/: lv_textarea.c
    ../lvgl/src/widgets/tileview/: lv_tileview.c
    ../lvgl/src/widgets/win/: lv_win.c
  group lvgl_theme
    ../lvgl/src/themes/default/: lv_theme_default.c
  group lvgl_layouts
    ../lvgl/src/layouts/flex/: lv_flex.c
    ../lvgl/src/layouts/grid/: lv_grid.c
  group ui
    ../ui/: ui_img_1524113965.c
  group sd_card
    ./sd/: sd_card.c sd_card.h
software components: CMSIS:CORE 5.3.0
